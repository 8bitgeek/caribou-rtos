# IAR project ftp_server_demo.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F4XX; USE_STM324xG_EVAL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\common\cmsis\include; ..\..\..\..\common\st\devices\stm32f4xx; ..\..\..\..\common\st\boards; ..\..\..\..\common\st\boards\common; ..\..\..\..\common\st\boards\stm324xg_eval; ..\..\..\..\common\st\stm32f4xx_std_periph_lib\inc; ..\..\..\..\common\freertos\include; ..\..\..\..\common\freertos\portable\keil\cortex_m4f; ..\..\..\..\common\fatfs; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_tcp\drivers; ..\..\..\..\..\cyclone_tcp\core; ..\..\..\..\..\cyclone_tcp\ipv4; ..\..\..\..\..\cyclone_tcp\ipv6; ..\..\..\..\..\cyclone_tcp\dns; ..\..\..\..\..\cyclone_tcp\mdns; ..\..\..\..\..\cyclone_tcp\dhcp; ..\..\..\..\..\cyclone_tcp\dhcpv6; ..\..\..\..\..\cyclone_tcp\ftp; ..\..\..\..\..\cyclone_tcp\http; ..\..\..\..\..\cyclone_tcp\smtp; ..\..\..\..\..\cyclone_tcp\sntp; ..\..\..\..\..\cyclone_tcp\icecast; ..\..\..\..\..\cyclone_tcp\std_services; ..\..\..\..\..\cyclone_crypto; ..\..\..\..\..\cyclone_ssl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32F4XX; USE_STM324xG_EVAL; USE_STDPERIPH_DRIVER
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ftp_server_demo.srec
  ILINK.IlinkOutputFile: ftp_server_demo.out
  ILINK.IlinkIcfFile: stm32f407_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32f407_sram.icf
configuration EXT SRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32f407_ext_sram.icf
  group Demo Sources
    ./: startup_stm32f4xx.s
    ../src/: system_stm32f4xx.c stm32f4xx_it.c main.c fatfs_drv.c debug.c
  group Demo Headers
    ../src/: os_port_config.h fs_port_config.h tcp_ip_stack_config.h freertosconfig.h ffconf.h stm32f4xx_conf.h stm32f4xx_it.h
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c fs_port_fatfs.c date_time.c str.c path.c
  group Common Headers
    ../../../../../common/: endian.h os_port.h os_port_freertos.h fs_port.h date_time.h str.h path.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.c tcp_ip_stack_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c ping.c
    ../../../../../cyclone_tcp/drivers/: stm32f4x7_eth.c dp83848.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_relay.c dhcpv6_common.c dhcpv6_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_server.c ftp_server_events.c ftp_server_commands.c ftp_server_misc.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.h tcp_ip_stack_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h ping.h
    ../../../../../cyclone_tcp/drivers/: stm32f4x7_eth.h dp83848.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_relay.h dhcpv6_common.h dhcpv6_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_server.h ftp_server_events.h ftp_server_commands.h ftp_server_misc.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/iar/cortex_m4f/: port.c portasm.s
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/iar/cortex_m4f/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FatFs Sources
    ../../../../common/fatfs/: ff.c
    ../../../../common/fatfs/option/: unicode.c
  group FatFs Headers
    ../../../../common/fatfs/: diskio.h ff.h integer.h
  group STM322xG-EVAL Sources
    ../../../../common/st/boards/stm324xg_eval/: stm324xg_eval.c stm324xg_eval_fsmc_sram.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c stm324xg_eval_sdio_sd.c
  group STM324xG-EVAL Headers
    ../../../../common/st/boards/stm324xg_eval/: stm324xg_eval.h stm324xg_eval_fsmc_sram.h stm324xg_eval_ioe.h stm324xg_eval_lcd.h stm324xg_eval_sdio_sd.h
  group STM32F4xx Std Periph Lib Sources
    ../../../../common/st/stm32f4xx_std_periph_lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4xx Std Periph Lib Headers
    ../../../../common/st/stm32f4xx_std_periph_lib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
