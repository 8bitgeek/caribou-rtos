# Keil uVision project web_server_demo.uvproj, settings and files
target web_server_demo_flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: web_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1
  c define: STM32F4XX USE_STM324xG_EVAL USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\st\devices\stm32f4xx;..\..\..\..\common\st\boards;..\..\..\..\common\st\boards\common;..\..\..\..\common\st\boards\stm324xg_eval;..\..\..\..\common\st\stm32f4xx_std_periph_lib\inc;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\keil\cortex_m4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_tcp\drivers;..\..\..\..\..\cyclone_tcp\core;..\..\..\..\..\cyclone_tcp\ipv4;..\..\..\..\..\cyclone_tcp\ipv6;..\..\..\..\..\cyclone_tcp\dns;..\..\..\..\..\cyclone_tcp\mdns;..\..\..\..\..\cyclone_tcp\dhcp;..\..\..\..\..\cyclone_tcp\dhcpv6;..\..\..\..\..\cyclone_tcp\ftp;..\..\..\..\..\cyclone_tcp\http;..\..\..\..\..\cyclone_tcp\smtp;..\..\..\..\..\cyclone_tcp\sntp;..\..\..\..\..\cyclone_tcp\icecast;..\..\..\..\..\cyclone_tcp\std_services;..\..\..\..\..\cyclone_crypto;..\..\..\..\..\cyclone_ssl
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407_flash.sct
  group Demo Sources
    ./: startup_stm32f4xx.s retarget.c
    ../src/: system_stm32f4xx.c stm32f4xx_it.c main.c debug.c res.c lis302dl.c
  group Demo Headers
    ../src/: os_port_config.h tcp_ip_stack_config.h tls_config.h crypto_config.h freertosconfig.h stm32f4xx_conf.h stm32f4xx_it.h lis302dl.h
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c date_time.c str.c resource_manager.c
  group Common Headers
    ../../../../../common/: endian.h os_port.h os_port_freertos.h date_time.h str.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.c tcp_ip_stack_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c ping.c
    ../../../../../cyclone_tcp/drivers/: stm32f4x7_eth.c dp83848.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_relay.c dhcpv6_common.c dhcpv6_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
    ../../../../../cyclone_tcp/http/: http_server.c mime.c ssi.c
    ../../../../../cyclone_tcp/smtp/: smtp_client.c
    ../../../../../cyclone_tcp/icecast/: icecast_client.c
    ../../../../../cyclone_tcp/std_services/: echo.c discard.c chargen.c daytime.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.h tcp_ip_stack_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h ping.h
    ../../../../../cyclone_tcp/drivers/: stm32f4x7_eth.h dp83848.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_relay.h dhcpv6_common.h dhcpv6_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
    ../../../../../cyclone_tcp/http/: http_server.h mime.h ssi.h
    ../../../../../cyclone_tcp/smtp/: smtp_client.h
    ../../../../../cyclone_tcp/icecast/: icecast_client.h
    ../../../../../cyclone_tcp/std_services/: echo.h discard.h chargen.h daytime.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_client.c tls_server.c tls_common.c tls_record.c tls_io.c tls_misc.c tls_cache.c ssl_common.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_client.h tls_server.h tls_common.h tls_record.h tls_io.h tls_cache.h tls_misc.h ssl_common.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/: base64.c md2.c md4.c md5.c ripemd128.c ripemd160.c sha1.c sha224.c sha256.c sha384.c sha512.c sha512_224.c sha512_256.c tiger.c whirlpool.c hmac.c rc4.c rc6.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c cipher_mode_ecb.c cipher_mode_cbc.c cipher_mode_cfb.c cipher_mode_ofb.c cipher_mode_ctr.c cipher_mode_ccm.c cipher_mode_gcm.c dh.c rsa.c dsa.c ec.c ec_curves.c ecdh.c ecdsa.c pkcs5.c mpi.c asn1.c x509.c pem.c yarrow.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/: crypto.h base64.h md2.h md4.h md5.h ripemd128.h ripemd160.h sha1.h sha224.h sha256.h sha384.h sha512.h sha512_224.h sha512_256.h tiger.h whirlpool.h hmac.h rc4.h rc6.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h cipher_mode_ecb.h cipher_mode_cbc.h cipher_mode_cfb.h cipher_mode_ofb.h cipher_mode_ctr.h cipher_mode_ccm.h cipher_mode_gcm.h dh.h rsa.h dsa.h ec.h ec_curves.h ecdh.h ecdsa.h pkcs5.h mpi.h asn1.h x509.h pem.h yarrow.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/keil/cortex_m4f/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/keil/cortex_m4f/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group STM324xG-EVAL Sources
    ../../../../common/st/boards/stm324xg_eval/: stm324xg_eval.c stm324xg_eval_fsmc_sram.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c
  group STM324xG-EVAL Headers
    ../../../../common/st/boards/stm324xg_eval/: stm324xg_eval.h stm324xg_eval_fsmc_sram.h stm324xg_eval_ioe.h stm324xg_eval_lcd.h
  group STM32F4xx Std Periph Lib Sources
    ../../../../common/st/stm32f4xx_std_periph_lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4xx Std Periph Lib Headers
    ../../../../common/st/stm32f4xx_std_periph_lib/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
target web_server_demo_sram (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: web_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1
  c define: STM32F4XX USE_STM324xG_EVAL USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407_sram.sct
target web_server_demo_ext_sram (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: as above
  output: web_server_demo_ext_sram
  BeforeMake: as above
  c flags: Optim=1
  c define: STM32F4XX USE_STM324xG_EVAL USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407_ext_sram.sct
