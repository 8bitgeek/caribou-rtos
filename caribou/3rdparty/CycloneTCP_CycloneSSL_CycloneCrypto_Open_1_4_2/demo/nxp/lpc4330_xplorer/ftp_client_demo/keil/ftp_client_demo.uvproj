# Keil uVision project ftp_client_demo.uvproj, settings and files
target ftp_client_demo_spifi (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: ftp_client_demo_spifi
  c flags: Optim=1
  c define: LPC4330 USE_LPC4330_XPLORER CMSIS_BITPOSITIONS
  c misc: --gnu
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\nxp\devices\lpc43xx;..\..\..\..\common\nxp\boards\common;..\..\..\..\common\nxp\boards\lpc4330_xplorer;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\keil\cortex_m4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_tcp\drivers;..\..\..\..\..\cyclone_tcp\core;..\..\..\..\..\cyclone_tcp\ipv4;..\..\..\..\..\cyclone_tcp\ipv6;..\..\..\..\..\cyclone_tcp\dns;..\..\..\..\..\cyclone_tcp\mdns;..\..\..\..\..\cyclone_tcp\dhcp;..\..\..\..\..\cyclone_tcp\dhcpv6;..\..\..\..\..\cyclone_tcp\ftp;..\..\..\..\..\cyclone_tcp\http;..\..\..\..\..\cyclone_tcp\smtp;..\..\..\..\..\cyclone_tcp\sntp;..\..\..\..\..\cyclone_tcp\icecast;..\..\..\..\..\cyclone_tcp\std_services;..\..\..\..\..\cyclone_crypto;..\..\..\..\..\cyclone_ssl
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\lpc4330_spifi.sct
  group Demo Sources
    ./: startup_lpc43xx.s retarget.c
    ../src/: system_lpc43xx.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h tcp_ip_stack_config.h freertosconfig.h
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.c tcp_ip_stack_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c ping.c
    ../../../../../cyclone_tcp/drivers/: lpc43xx_eth.c lan8720.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_relay.c dhcpv6_common.c dhcpv6_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.h tcp_ip_stack_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h ping.h
    ../../../../../cyclone_tcp/drivers/: lpc43xx_eth.h lan8720.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_relay.h dhcpv6_common.h dhcpv6_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/keil/cortex_m4f/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/keil/cortex_m4f/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group LPC4330-Xplorer Headers
    ../../../../common/nxp/boards/lpc4330_xplorer/: lpc4330_xplorer.h
target ftp_client_demo_sram (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: as above
  output: ftp_client_demo_sram
  c flags: Optim=1
  c define: LPC4330 USE_LPC4330_XPLORER CMSIS_BITPOSITIONS
  c misc: --gnu
  c include: as above
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\lpc4330_sram.sct
