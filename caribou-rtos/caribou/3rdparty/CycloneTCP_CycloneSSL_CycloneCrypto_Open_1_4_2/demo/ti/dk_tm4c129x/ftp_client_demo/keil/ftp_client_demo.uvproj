# Keil uVision project ftp_client_demo.uvproj, settings and files
target ftp_client_demo_flash (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ftp_client_demo_flash
  c flags: Optim=1
  c define: PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0 USE_DK_TM4C129X
  c misc: --gnu
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\ti\devices\tm4c129x;..\..\..\..\common\ti\boards\dk_tm4c129x;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\keil\cortex_m4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_tcp\drivers;..\..\..\..\..\cyclone_tcp\core;..\..\..\..\..\cyclone_tcp\ipv4;..\..\..\..\..\cyclone_tcp\ipv6;..\..\..\..\..\cyclone_tcp\dns;..\..\..\..\..\cyclone_tcp\mdns;..\..\..\..\..\cyclone_tcp\dhcp;..\..\..\..\..\cyclone_tcp\dhcpv6;..\..\..\..\..\cyclone_tcp\ftp;..\..\..\..\..\cyclone_tcp\http;..\..\..\..\..\cyclone_tcp\smtp;..\..\..\..\..\cyclone_tcp\sntp;..\..\..\..\..\cyclone_tcp\icecast;..\..\..\..\..\cyclone_tcp\std_services;..\..\..\..\..\cyclone_crypto;..\..\..\..\..\cyclone_ssl
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\tm4c129x_flash.sct
  group Demo Sources
    ./: startup_tm4c129x.s retarget.c
    ../src/: system_tm4c129x.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h tcp_ip_stack_config.h freertosconfig.h
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.c tcp_ip_stack_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c ping.c
    ../../../../../cyclone_tcp/drivers/: tm4c129x_eth.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.h tcp_ip_stack_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h ping.h
    ../../../../../cyclone_tcp/drivers/: tm4c129x_eth.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/keil/cortex_m4f/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/keil/cortex_m4f/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group DK-TM4X129X Sources
    ../../../../common/ti/boards/dk_tm4c129x/drivers/: pinout.c kentec320x240x16_ssd2119.c
    ../../../../common/ti/boards/dk_tm4c129x/grlib/: context.c string.c charmap.c
    ../../../../common/ti/boards/dk_tm4c129x/grlib/fonts/: fontcmss18.c fontcmss18b.c fontfixed6x8.c
  group DK-TM4X129X Headers
    ../../../../common/ti/boards/dk_tm4c129x/drivers/: pinout.h kentec320x240x16_ssd2119.h
    ../../../../common/ti/boards/dk_tm4c129x/grlib/: grlib.h
  group Tiva Periph Driver Lib Sources
    ../../../../common/ti/devices/tm4c129x/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Tiva Periph Driver Lib Headers
    ../../../../common/ti/devices/tm4c129x/driverlib/: adc.h aes.h can.h comp.h cpu.h crc.h des.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h i2c.h interrupt.h lcd.h mpu.h pin_map.h pwm.h qei.h rom.h rom_map.h rtos_bindings.h shamd5.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h uart.h udma.h usb.h watchdog.h
target ftp_client_demo_sram (ARM-ADS)
  device: TM4C129XNCZAD Texas Instruments
  cpu: as above
  output: ftp_client_demo_sram
  c flags: Optim=1
  c define: PART_TM4C129XNCZAD TARGET_IS_SNOWFLAKE_RA0 USE_DK_TM4C129X
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\tm4c129x_sram.sct
