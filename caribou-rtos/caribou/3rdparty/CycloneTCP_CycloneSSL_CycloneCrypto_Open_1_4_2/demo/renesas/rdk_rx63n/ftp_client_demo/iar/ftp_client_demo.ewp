# IAR project ftp_client_demo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x10000
  ICCRX.CCDefines: RX63NB; USE_RDK_RX63N
  ICCRX.CCIncludePath2: ..\src; ..\..\..\..\common\renesas\boards\rdk_rx63n; ..\..\..\..\common\freertos\include; ..\..\..\..\common\freertos\portable\iar\rx600; ..\..\..\..\..\common; ..\..\..\..\..\cyclone_tcp; ..\..\..\..\..\cyclone_tcp\drivers; ..\..\..\..\..\cyclone_tcp\core; ..\..\..\..\..\cyclone_tcp\ipv4; ..\..\..\..\..\cyclone_tcp\ipv6; ..\..\..\..\..\cyclone_tcp\dns; ..\..\..\..\..\cyclone_tcp\mdns; ..\..\..\..\..\cyclone_tcp\dhcp; ..\..\..\..\..\cyclone_tcp\dhcpv6; ..\..\..\..\..\cyclone_tcp\ftp; ..\..\..\..\..\cyclone_tcp\http; ..\..\..\..\..\cyclone_tcp\smtp; ..\..\..\..\..\cyclone_tcp\sntp; ..\..\..\..\..\cyclone_tcp\icecast; ..\..\..\..\..\cyclone_tcp\std_services; ..\..\..\..\..\cyclone_crypto; ..\..\..\..\..\cyclone_ssl
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: ..\src
  ILINK.IlinkOutputFile: ftp_client_demo.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  group Demo Sources
    ../src/: low_level_init.c hwsetup.c main.c debug.c
  group Demo Headers
    ../src/: mcu_info.h hwsetup.h os_port_config.h tcp_ip_stack_config.h freertosconfig.h
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.c tcp_ip_stack_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c ping.c
    ../../../../../cyclone_tcp/drivers/: rx63n_eth.c dp83620.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_relay.c dhcpv6_common.c dhcpv6_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.h tcp_ip_stack_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h ping.h
    ../../../../../cyclone_tcp/drivers/: rx63n_eth.h dp83620.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_relay.h dhcpv6_common.h dhcpv6_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/iar/rx600/: port.c portasm.s
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/iar/rx600/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group RDK RX63N Sources
    ../../../../common/renesas/boards/rdk_rx63n/: r_rspi_rx600.c glyph.c r_glyph.c r_glyph_register.c st7579_lcd.c font_8x8.c
  group RDK RX63N Headers
    ../../../../common/renesas/boards/rdk_rx63n/: yrdkrx63n.h r_rspi_rx600.h r_rspi_rx600_config.h glyph.h glyph_config.h glyph_preamble.h r_glyph.h r_glyph_config.h st7579_lcd.h
