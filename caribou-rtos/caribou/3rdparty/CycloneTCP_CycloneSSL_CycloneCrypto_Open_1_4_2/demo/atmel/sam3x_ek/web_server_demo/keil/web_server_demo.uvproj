# Keil uVision project web_server_demo.uvproj, settings and files
target web_server_demo_flash (ARM-ADS)
  device: SAM3X8H Atmel
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x20080000-0x20087FFF) IROM(0x80000-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: web_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1
  c define: __SAM3X8H__ USE_SAM3X_EK
  c misc: --gnu
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\atmel\devices\sam3xa;..\..\..\..\common\atmel\boards\common;..\..\..\..\common\atmel\boards\sam3x_ek;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\keil\cortex_m3;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_tcp\drivers;..\..\..\..\..\cyclone_tcp\core;..\..\..\..\..\cyclone_tcp\ipv4;..\..\..\..\..\cyclone_tcp\ipv6;..\..\..\..\..\cyclone_tcp\dns;..\..\..\..\..\cyclone_tcp\mdns;..\..\..\..\..\cyclone_tcp\dhcp;..\..\..\..\..\cyclone_tcp\dhcpv6;..\..\..\..\..\cyclone_tcp\ftp;..\..\..\..\..\cyclone_tcp\http;..\..\..\..\..\cyclone_tcp\smtp;..\..\..\..\..\cyclone_tcp\sntp;..\..\..\..\..\cyclone_tcp\icecast;..\..\..\..\..\cyclone_tcp\std_services;..\..\..\..\..\cyclone_crypto;..\..\..\..\..\cyclone_ssl
  memory RVCT4: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
  scatter file: .\sam3x_flash.sct
  group Demo Sources
    ./: startup_sam3x.s retarget.c
    ../src/: system_sam3x.c main.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h tcp_ip_stack_config.h tls_config.h crypto_config.h freertosconfig.h
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c date_time.c str.c resource_manager.c
  group Common Headers
    ../../../../../common/: endian.h os_port.h os_port_freertos.h date_time.h str.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.c tcp_ip_stack_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c ping.c
    ../../../../../cyclone_tcp/drivers/: sam3x_eth.c dm9161.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_relay.c dhcpv6_common.c dhcpv6_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
    ../../../../../cyclone_tcp/http/: http_server.c mime.c ssi.c
    ../../../../../cyclone_tcp/smtp/: smtp_client.c
    ../../../../../cyclone_tcp/icecast/: icecast_client.c
    ../../../../../cyclone_tcp/std_services/: echo.c discard.c chargen.c daytime.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.h tcp_ip_stack_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h ping.h
    ../../../../../cyclone_tcp/drivers/: sam3x_eth.h dm9161.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_relay.h dhcpv6_common.h dhcpv6_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
    ../../../../../cyclone_tcp/http/: http_server.h mime.h ssi.h
    ../../../../../cyclone_tcp/smtp/: smtp_client.h
    ../../../../../cyclone_tcp/icecast/: icecast_client.h
    ../../../../../cyclone_tcp/std_services/: echo.h discard.h chargen.h daytime.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_client.c tls_server.c tls_common.c tls_record.c tls_io.c tls_misc.c tls_cache.c ssl_common.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_client.h tls_server.h tls_common.h tls_record.h tls_io.h tls_cache.h tls_misc.h ssl_common.h
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/: base64.c md2.c md4.c md5.c ripemd128.c ripemd160.c sha1.c sha224.c sha256.c sha384.c sha512.c sha512_224.c sha512_256.c tiger.c whirlpool.c hmac.c rc4.c rc6.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c cipher_mode_ecb.c cipher_mode_cbc.c cipher_mode_cfb.c cipher_mode_ofb.c cipher_mode_ctr.c cipher_mode_ccm.c cipher_mode_gcm.c dh.c rsa.c dsa.c ec.c ec_curves.c ecdh.c ecdsa.c pkcs5.c mpi.c asn1.c x509.c pem.c yarrow.c
  group CycloneCrypto Headers
    ../../../../../cyclone_crypto/: crypto.h base64.h md2.h md4.h md5.h ripemd128.h ripemd160.h sha1.h sha224.h sha256.h sha384.h sha512.h sha512_224.h sha512_256.h tiger.h whirlpool.h hmac.h rc4.h rc6.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h cipher_mode_ecb.h cipher_mode_cbc.h cipher_mode_cfb.h cipher_mode_ofb.h cipher_mode_ctr.h cipher_mode_ccm.h cipher_mode_gcm.h dh.h rsa.h dsa.h ec.h ec_curves.h ecdh.h ecdsa.h pkcs5.h mpi.h asn1.h x509.h pem.h yarrow.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/keil/cortex_m3/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/keil/cortex_m3/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group SAM3X-EK Source
    ../../../../common/atmel/boards/sam3x_ek/: sdram.c lcd.c
  group SAM3X-EK Headers
    ../../../../common/atmel/boards/sam3x_ek/: sam3x_ek.h sdram.h lcd.h
target web_server_demo_sram (ARM-ADS)
  device: SAM3X8H Atmel
  cpu: as above
  output: web_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1
  c define: __SAM3X8H__ USE_SAM3X_EK
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
  scatter file: .\sam3x_sram.sct
target web_server_demo_sdram (ARM-ADS)
  device: SAM3X8H Atmel
  cpu: as above
  output: web_server_demo_sdram
  BeforeMake: as above
  c flags: Optim=1
  c define: __SAM3X8H__ USE_SAM3X_EK
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
  scatter file: .\sam3x_sdram.sct
